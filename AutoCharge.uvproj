# Keil uVision project AutoCharge.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: AutoCharge +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 AutoCharge.h AutoCharge.c OledControl.h OledControl.c PWM.c PWM.h CountDown.h CountDown.c
